# Keil uVision project Template_UCOSIII.uvprojx, settings and files
target Template_UCOSIII (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: APP +hex
  c flags: Optim=1 wLevel=2
  c include: .\;..\..\..\1_Processor\STM32F1\Start_Code;..\..\..\1_Processor\STM32F1\Start_Code\CMSIS;..\..\..\1_Processor\STM32F1\Start_Code\FWlib\inc;..\..\..\1_Processor\STM32F1\BSP;..\..\..\3_OS\STM32F1\RTOS\uCOS-III\uC-CPU;..\..\..\3_OS\STM32F1\RTOS\uCOS-III\uC-CPU\ARM-Cortex-M3\RealView;..\..\..\3_OS\STM32F1\RTOS\uCOS-III\uC-LIB;..\..\..\3_OS\STM32F1\RTOS\uCOS-III\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\..\..\3_OS\STM32F1\RTOS\uCOS-III\uCOS-III;..\..\..\3_OS\STM32F1\RTOS\uCOS-III\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\..\3_OS\STM32F1\RTOS\uCOS-III\uCOS-III\Source;..\..\..\3_OS\STM32F1\RTOS\uCOS-III\UCOS-BSP;..\..\..\3_OS\STM32F1\RTOS\uCOS-III\uCOS-CONFIG
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c main_includes.h main_config.h stm32f10x_it.c
  group Start_Code
    ../../../1_Processor/STM32F1/Start_Code/: stm32f10x_conf.h
    ../../../1_Processor/STM32F1/Start_Code/CMSIS/startup/: startup_stm32f10x_hd.s
    ../../../1_Processor/STM32F1/Start_Code/CMSIS/: core_cm3.c system_stm32f10x.c
    ../../../1_Processor/STM32F1/Start_Code/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../../../1_Processor/STM32F1/BSP/: BSP_TOP.c BSP_TOP.h nvic.c nvic.h delay.c delay.h rtc.c rtc.h wdg_wkup.c wdg_wkup.h flash.c flash.h led_key.c led_key.h usart.c usart.h adc_dac.c adc_dac.h timer.c timer.h pwm_in.c pwm_in.h pwm_out.c pwm_out.h encoder.c encoder.h i2c.c i2c.h can.c can.h spi.c spi.h
  group OS/RTOS/UCOSIII-BSP
    ../../../3_OS/STM32F1/RTOS/uCOS-III/uCOS-BSP/: bsp.c bsp.h
  group OS/RTOS/UCOSIII-CPU
    ../../../3_OS/STM32F1/RTOS/uCOS-III/uC-CPU/: cpu_core.c
    ../../../3_OS/STM32F1/RTOS/uCOS-III/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group OS/RTOS/UCOSIII-LIB
    ../../../3_OS/STM32F1/RTOS/uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../3_OS/STM32F1/RTOS/uCOS-III/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group OS/RTOS/UCOSIII-CORE
    ../../../3_OS/STM32F1/RTOS/uCOS-III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group OS/RTOS/UCOSIII-PORT
    ../../../3_OS/STM32F1/RTOS/uCOS-III/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_c.c os_cpu_a.s
  group OS/RTOS/UCOSIII-CONFIG
    ../../../3_OS/STM32F1/RTOS/uCOS-III/uCOS-CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
